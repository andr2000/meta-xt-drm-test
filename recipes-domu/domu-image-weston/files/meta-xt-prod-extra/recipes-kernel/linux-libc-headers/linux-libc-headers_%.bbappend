RENESAS_BSP_URL = "git://github.com/andr2000/linux.git"

BRANCH = "drm_pre_v0"
SRCREV = "${AUTOREV}"
